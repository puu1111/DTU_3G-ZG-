# Keil uVision project STM32F051R8_Demo.uvprojx, settings and files
target STM32F051R8_Demo (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IO_Toggle +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F072
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\BSP;..\..\..\FONTS;..\Source;..\Source\include;..\Source\portable\RVDS\ARM_CM0;..\STM32F0xx_StdPeriph_Driver\inc;..\BSP;..\Include;..\modbus;..\modbus\Port;..\modbus\include;..\paho\MQTTPacket;..\paho;..\modbus\include\common;..\BSP\FatFs;..\BSP\FatFs\src;..\BSP\FatFs\src\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c
    ../Source/: FreeRTOSConfig.h
  group BSP
    ../BSP/: BSP_LED.c 3gmodule.c datapacket.c datetime.c setting.c stm320xx8_rtu.c stm320518_i2c_ee.c DTU_test.c CH395.C CH395CMD.C CH395UART.C spi.c mmc_sd.c TM7706.c 24cxx.c soft_I2C.c N-6000.c mycc936.c N_6205.C
    ../modbus/: mbmul.c
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group MDK-ARM
    ../: startup_stm32f072.s
  group FreeRTOS/Source
    ../Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c timertask.c
  group FreeRTOS/Prots
    ../Source/portable/MemMang/: heap_2.c
    ../Source/portable/RVDS/ARM_CM0/: port.c
  group paho
    ../paho/: qos0pub.c transport.c
    ../paho/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Fafts
    ../BSP/FatFs/src/: diskio.c fatfs.c ff.c ff_gen_drv.c user_diskio.c
    ../BSP/FatFs/src/option/: syscall.c
    ../Source/: cmsis_os.c
software components: Data Exchange:JSON:Jansson 2.7.0
